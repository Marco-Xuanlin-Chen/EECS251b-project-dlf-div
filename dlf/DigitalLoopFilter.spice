$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
*.BUSDELIMITER [

.SUBCKT DigitalLoopFilter reset enable clock TDC_out[5] TDC_out[4] TDC_out[3]
+ TDC_out[2] TDC_out[1] TDC_out[0] Kp[11] Kp[10] Kp[9] Kp[8] Kp[7] Kp[6] Kp[5]
+ Kp[4] Kp[3] Kp[2] Kp[1] Kp[0] Ki[11] Ki[10] Ki[9] Ki[8] Ki[7] Ki[6] Ki[5]
+ Ki[4] Ki[3] Ki[2] Ki[1] Ki[0] DLF_out[4] DLF_out[3] DLF_out[2] DLF_out[1]
+ DLF_out[0]
Xintegrated_reg[6] clock n_5 VGND VNB VPB VPWR integrated[6]
+ sky130_fd_sc_hd__dfxtp_1
Xintegrated_reg[7] clock n_6 VGND VNB VPB VPWR integrated[7]
+ sky130_fd_sc_hd__dfxtp_1
Xintegrated_reg[8] clock n_4 VGND VNB VPB VPWR integrated[8]
+ sky130_fd_sc_hd__dfxtp_1
Xintegrated_reg[9] clock n_2 VGND VNB VPB VPWR integrated[9]
+ sky130_fd_sc_hd__dfxtp_1
Xintegrated_reg[10] clock n_3 VGND VNB VPB VPWR integrated[10]
+ sky130_fd_sc_hd__dfxtp_1
Xintegrated_reg[11] clock n_1 VGND VNB VPB VPWR integrated[11]
+ sky130_fd_sc_hd__dfxtp_1
Xg44__2398 n_0 preintegration[7] VGND VNB VPB VPWR n_6
+ sky130_fd_sc_hd__nor2b_1
Xg45__5107 n_0 preintegration[6] VGND VNB VPB VPWR n_5
+ sky130_fd_sc_hd__nor2b_1
Xg46__6260 n_0 preintegration[8] VGND VNB VPB VPWR n_4
+ sky130_fd_sc_hd__nor2b_1
Xg47__4319 n_0 preintegration[10] VGND VNB VPB VPWR n_3
+ sky130_fd_sc_hd__nor2b_1
Xg48__8428 n_0 preintegration[9] VGND VNB VPB VPWR n_2
+ sky130_fd_sc_hd__nor2b_1
Xg49__5526 n_0 preintegration[11] VGND VNB VPB VPWR n_1
+ sky130_fd_sc_hd__nor2b_1
Xg50__6783 reset enable VGND VNB VPB VPWR n_0 sky130_fd_sc_hd__nand2b_1
XWALLACE_CSA_DUMMY_OP_groupi_g1355__3680 WALLACE_CSA_DUMMY_OP_groupi_n_63
+ WALLACE_CSA_DUMMY_OP_groupi_n_66 VGND VNB VPB VPWR preintegration[11]
+ sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1356__1617 WALLACE_CSA_DUMMY_OP_groupi_n_57
+ WALLACE_CSA_DUMMY_OP_groupi_n_60 WALLACE_CSA_DUMMY_OP_groupi_n_64 1056 1057
+ 1058 1059 WALLACE_CSA_DUMMY_OP_groupi_n_66 preintegration[10]
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1357__2802 WALLACE_CSA_DUMMY_OP_groupi_n_58
+ integrated[9] WALLACE_CSA_DUMMY_OP_groupi_n_61 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_64 preintegration[9] sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1358__1705 WALLACE_CSA_DUMMY_OP_groupi_n_56
+ WALLACE_CSA_DUMMY_OP_groupi_n_59 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_63 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1359__5122 WALLACE_CSA_DUMMY_OP_groupi_n_48
+ integrated[8] WALLACE_CSA_DUMMY_OP_groupi_n_54 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_61 preintegration[8] sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1360__8246 WALLACE_CSA_DUMMY_OP_groupi_n_46
+ WALLACE_CSA_DUMMY_OP_groupi_n_52 integrated[10] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_59 WALLACE_CSA_DUMMY_OP_groupi_n_60
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1361__7098 WALLACE_CSA_DUMMY_OP_groupi_n_29
+ WALLACE_CSA_DUMMY_OP_groupi_n_50 WALLACE_CSA_DUMMY_OP_groupi_n_47 1076 1077
+ 1078 1079 WALLACE_CSA_DUMMY_OP_groupi_n_57 WALLACE_CSA_DUMMY_OP_groupi_n_58
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1362__6131 WALLACE_CSA_DUMMY_OP_groupi_n_53
+ integrated[11] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_56
+ sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1363__1881 WALLACE_CSA_DUMMY_OP_groupi_n_44
+ integrated[7] WALLACE_CSA_DUMMY_OP_groupi_n_35 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_54 preintegration[7] sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1364__5115 WALLACE_CSA_DUMMY_OP_groupi_n_51
+ WALLACE_CSA_DUMMY_OP_groupi_n_49 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_53 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1365__7482 WALLACE_CSA_DUMMY_OP_groupi_n_26
+ WALLACE_CSA_DUMMY_OP_groupi_n_31 WALLACE_CSA_DUMMY_OP_groupi_n_39 1092 1093
+ 1094 1095 WALLACE_CSA_DUMMY_OP_groupi_n_51 WALLACE_CSA_DUMMY_OP_groupi_n_52
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi_g1366__4733 WALLACE_CSA_DUMMY_OP_groupi_n_27
+ WALLACE_CSA_DUMMY_OP_groupi_n_45 WALLACE_CSA_DUMMY_OP_groupi_n_32 1096 1097
+ 1098 1099 WALLACE_CSA_DUMMY_OP_groupi_n_50 sky130_fd_sc_hd__o21a_1
XWALLACE_CSA_DUMMY_OP_groupi_g1367__6161 WALLACE_CSA_DUMMY_OP_groupi_n_43
+ WALLACE_CSA_DUMMY_OP_groupi_n_42 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_49 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1368__9315 WALLACE_CSA_DUMMY_OP_groupi_n_45
+ WALLACE_CSA_DUMMY_OP_groupi_n_41 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_48 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1369__9945 WALLACE_CSA_DUMMY_OP_groupi_n_34
+ WALLACE_CSA_DUMMY_OP_groupi_n_37 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_46 WALLACE_CSA_DUMMY_OP_groupi_n_47
+ sky130_fd_sc_hd__ha_1
XWALLACE_CSA_DUMMY_OP_groupi_g1370__2883 WALLACE_CSA_DUMMY_OP_groupi_n_14
+ WALLACE_CSA_DUMMY_OP_groupi_n_28 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_45 WALLACE_CSA_DUMMY_OP_groupi_n_44
+ sky130_fd_sc_hd__ha_1
XWALLACE_CSA_DUMMY_OP_groupi_g1371__2346 WALLACE_CSA_DUMMY_OP_groupi_n_33
+ WALLACE_CSA_DUMMY_OP_groupi_n_40 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_43 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1372__1666 WALLACE_CSA_DUMMY_OP_groupi_n_30
+ WALLACE_CSA_DUMMY_OP_groupi_n_38 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_42 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1373__7410 WALLACE_CSA_DUMMY_OP_groupi_n_32
+ WALLACE_CSA_DUMMY_OP_groupi_n_27 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_41 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1374__6417 WALLACE_CSA_DUMMY_OP_groupi_n_11
+ WALLACE_CSA_DUMMY_OP_groupi_n_6 WALLACE_CSA_DUMMY_OP_groupi_n_7
+ WALLACE_CSA_DUMMY_OP_groupi_n_25 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_40 sky130_fd_sc_hd__a31oi_1
XWALLACE_CSA_DUMMY_OP_groupi_g1375__5477 WALLACE_CSA_DUMMY_OP_groupi_n_12
+ WALLACE_CSA_DUMMY_OP_groupi_n_24 WALLACE_CSA_DUMMY_OP_groupi_n_13
+ WALLACE_CSA_DUMMY_OP_groupi_n_17 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_39 sky130_fd_sc_hd__o22ai_1
XWALLACE_CSA_DUMMY_OP_groupi_g1376__2398 WALLACE_CSA_DUMMY_OP_groupi_n_13
+ WALLACE_CSA_DUMMY_OP_groupi_n_24 WALLACE_CSA_DUMMY_OP_groupi_n_15
+ WALLACE_CSA_DUMMY_OP_groupi_n_17 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_38 sky130_fd_sc_hd__o22ai_1
XWALLACE_CSA_DUMMY_OP_groupi_g1377__5107 WALLACE_CSA_DUMMY_OP_groupi_n_9
+ WALLACE_CSA_DUMMY_OP_groupi_n_24 WALLACE_CSA_DUMMY_OP_groupi_n_12
+ WALLACE_CSA_DUMMY_OP_groupi_n_17 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_37 sky130_fd_sc_hd__o22ai_1
XWALLACE_CSA_DUMMY_OP_groupi_g1378__6260 WALLACE_CSA_DUMMY_OP_groupi_n_5
+ integrated[6] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_35
+ preintegration[6] sky130_fd_sc_hd__ha_1
XWALLACE_CSA_DUMMY_OP_groupi_g1379__4319 WALLACE_CSA_DUMMY_OP_groupi_n_2
+ WALLACE_CSA_DUMMY_OP_groupi_n_22 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_34 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1380__8428 WALLACE_CSA_DUMMY_OP_groupi_n_23
+ TDC_out[5] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_33
+ sky130_fd_sc_hd__nor2b_1
XWALLACE_CSA_DUMMY_OP_groupi_g1381__5526 WALLACE_CSA_DUMMY_OP_groupi_n_18
+ WALLACE_CSA_DUMMY_OP_groupi_n_4 WALLACE_CSA_DUMMY_OP_groupi_n_19 TDC_out[0]
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_32 sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi_g1382__6783 WALLACE_CSA_DUMMY_OP_groupi_n_21
+ WALLACE_CSA_DUMMY_OP_groupi_n_4 WALLACE_CSA_DUMMY_OP_groupi_n_20 TDC_out[0]
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_31 sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi_g1383__3680 WALLACE_CSA_DUMMY_OP_groupi_n_20
+ WALLACE_CSA_DUMMY_OP_groupi_n_4 WALLACE_CSA_DUMMY_OP_groupi_n_16 TDC_out[0]
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_30 sky130_fd_sc_hd__a22oi_1
XWALLACE_CSA_DUMMY_OP_groupi_g1384__1617 WALLACE_CSA_DUMMY_OP_groupi_n_19
+ WALLACE_CSA_DUMMY_OP_groupi_n_4 WALLACE_CSA_DUMMY_OP_groupi_n_21 TDC_out[0]
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_29 sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi_g1385__2802 WALLACE_CSA_DUMMY_OP_groupi_n_18
+ TDC_out[0] WALLACE_CSA_DUMMY_OP_groupi_n_4 WALLACE_CSA_DUMMY_OP_groupi_n_3
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_28 sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi_g1386__1705 WALLACE_CSA_DUMMY_OP_groupi_n_3
+ WALLACE_CSA_DUMMY_OP_groupi_n_17 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_27 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1387__5122 WALLACE_CSA_DUMMY_OP_groupi_n_3
+ WALLACE_CSA_DUMMY_OP_groupi_n_11 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_26 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1388__8246 WALLACE_CSA_DUMMY_OP_groupi_n_8
+ WALLACE_CSA_DUMMY_OP_groupi_n_11 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_25 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1389__7098 WALLACE_CSA_DUMMY_OP_groupi_n_17
+ WALLACE_CSA_DUMMY_OP_groupi_n_10 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_24 sky130_fd_sc_hd__nand2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1390__6131 Ki[0] TDC_out[3] TDC_out[4] 1192 1193
+ 1194 1195 WALLACE_CSA_DUMMY_OP_groupi_n_23 sky130_fd_sc_hd__maj3_1
XWALLACE_CSA_DUMMY_OP_groupi_g1391__1881 Ki[0] TDC_out[1] TDC_out[2] 1196 1197
+ 1198 1199 WALLACE_CSA_DUMMY_OP_groupi_n_22 sky130_fd_sc_hd__maj3_1
XWALLACE_CSA_DUMMY_OP_groupi_g1392__5115 TDC_out[1] Ki[5] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_16 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1393__7482 Ki[3] WALLACE_CSA_DUMMY_OP_groupi_n_2
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_15 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1394__4733 TDC_out[1] Ki[3] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_21 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1395__6161 TDC_out[1] Ki[4] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_20 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1396__9315 TDC_out[1] Ki[2] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_19 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1397__9945 TDC_out[1] Ki[1] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_18 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1398__2883 WALLACE_CSA_DUMMY_OP_groupi_n_1
+ WALLACE_CSA_DUMMY_OP_groupi_n_5 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_14 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1399__2346 TDC_out[1] TDC_out[2] 1228 1229 1230
+ 1231 WALLACE_CSA_DUMMY_OP_groupi_n_17 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1400__1666 TDC_out[2] TDC_out[3] 1232 1233 1234
+ 1235 WALLACE_CSA_DUMMY_OP_groupi_n_10 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1401__7410 TDC_out[3]
+ WALLACE_CSA_DUMMY_OP_groupi_n_3 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_9 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1402__6417 TDC_out[5] Ki[1] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_8 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1403__5477 TDC_out[4] TDC_out[5] 1244 1245 1246
+ 1247 WALLACE_CSA_DUMMY_OP_groupi_n_7 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1404__2398 TDC_out[5] Ki[0] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_6 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1405__5107 Ki[2] WALLACE_CSA_DUMMY_OP_groupi_n_2
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_13 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1406__6260 Ki[1] WALLACE_CSA_DUMMY_OP_groupi_n_2
+ VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi_n_12 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1407__4319 TDC_out[4]
+ WALLACE_CSA_DUMMY_OP_groupi_n_2 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_11 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1408__8428 Ki[0] TDC_out[0] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_5 sky130_fd_sc_hd__and2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1409__5526 TDC_out[0]
+ WALLACE_CSA_DUMMY_OP_groupi_n_1 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_4 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi_g1410 Ki[0] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_3 sky130_fd_sc_hd__inv_2
XWALLACE_CSA_DUMMY_OP_groupi_g1411 TDC_out[3] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_2 sky130_fd_sc_hd__inv_2
XWALLACE_CSA_DUMMY_OP_groupi_g1412 TDC_out[1] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi_n_1 sky130_fd_sc_hd__clkinv_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1321__6783 WALLACE_CSA_DUMMY_OP_groupi32_n_61
+ WALLACE_CSA_DUMMY_OP_groupi32_n_64 WALLACE_CSA_DUMMY_OP_groupi32_n_68 1284
+ 1285 1286 1287 WALLACE_CSA_DUMMY_OP_groupi32_n_70
+ WALLACE_CSA_DUMMY_OP_groupi32_n_71 sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1322__3680 WALLACE_CSA_DUMMY_OP_groupi32_n_62
+ integrated[9] WALLACE_CSA_DUMMY_OP_groupi32_n_65 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_68 WALLACE_CSA_DUMMY_OP_groupi32_n_69
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1324__1617 WALLACE_CSA_DUMMY_OP_groupi32_n_60
+ WALLACE_CSA_DUMMY_OP_groupi32_n_63 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_67 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1325__2802 WALLACE_CSA_DUMMY_OP_groupi32_n_52
+ integrated[8] WALLACE_CSA_DUMMY_OP_groupi32_n_58 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_65 WALLACE_CSA_DUMMY_OP_groupi32_n_66
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1326__1705 WALLACE_CSA_DUMMY_OP_groupi32_n_50
+ WALLACE_CSA_DUMMY_OP_groupi32_n_56 integrated[10] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_63 WALLACE_CSA_DUMMY_OP_groupi32_n_64
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1327__5122 WALLACE_CSA_DUMMY_OP_groupi32_n_35
+ WALLACE_CSA_DUMMY_OP_groupi32_n_54 WALLACE_CSA_DUMMY_OP_groupi32_n_51 1304
+ 1305 1306 1307 WALLACE_CSA_DUMMY_OP_groupi32_n_61
+ WALLACE_CSA_DUMMY_OP_groupi32_n_62 sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1328__8246 WALLACE_CSA_DUMMY_OP_groupi32_n_57
+ integrated[11] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_60
+ sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1329__7098 WALLACE_CSA_DUMMY_OP_groupi32_n_48
+ integrated[7] WALLACE_CSA_DUMMY_OP_groupi32_n_20 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_58 WALLACE_CSA_DUMMY_OP_groupi32_n_59
+ sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1330__6131 WALLACE_CSA_DUMMY_OP_groupi32_n_55
+ WALLACE_CSA_DUMMY_OP_groupi32_n_53 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_57 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1331__1881 WALLACE_CSA_DUMMY_OP_groupi32_n_33
+ WALLACE_CSA_DUMMY_OP_groupi32_n_38 WALLACE_CSA_DUMMY_OP_groupi32_n_43 1320
+ 1321 1322 1323 WALLACE_CSA_DUMMY_OP_groupi32_n_55
+ WALLACE_CSA_DUMMY_OP_groupi32_n_56 sky130_fd_sc_hd__fa_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1332__5115 WALLACE_CSA_DUMMY_OP_groupi32_n_32
+ WALLACE_CSA_DUMMY_OP_groupi32_n_49 WALLACE_CSA_DUMMY_OP_groupi32_n_36 1324
+ 1325 1326 1327 WALLACE_CSA_DUMMY_OP_groupi32_n_54 sky130_fd_sc_hd__o21a_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1333__7482 WALLACE_CSA_DUMMY_OP_groupi32_n_47
+ WALLACE_CSA_DUMMY_OP_groupi32_n_46 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_53 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1334__4733 WALLACE_CSA_DUMMY_OP_groupi32_n_49
+ WALLACE_CSA_DUMMY_OP_groupi32_n_45 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_52 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1335__6161 WALLACE_CSA_DUMMY_OP_groupi32_n_39
+ WALLACE_CSA_DUMMY_OP_groupi32_n_41 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_50 WALLACE_CSA_DUMMY_OP_groupi32_n_51
+ sky130_fd_sc_hd__ha_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1336__9315 WALLACE_CSA_DUMMY_OP_groupi32_n_21
+ WALLACE_CSA_DUMMY_OP_groupi32_n_34 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_49 WALLACE_CSA_DUMMY_OP_groupi32_n_48
+ sky130_fd_sc_hd__ha_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1337__9945 WALLACE_CSA_DUMMY_OP_groupi32_n_40
+ WALLACE_CSA_DUMMY_OP_groupi32_n_44 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_47 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1338__2883 WALLACE_CSA_DUMMY_OP_groupi32_n_37
+ WALLACE_CSA_DUMMY_OP_groupi32_n_42 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_46 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1339__2346 WALLACE_CSA_DUMMY_OP_groupi32_n_36
+ WALLACE_CSA_DUMMY_OP_groupi32_n_32 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_45 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1340__1666 WALLACE_CSA_DUMMY_OP_groupi32_n_17
+ WALLACE_CSA_DUMMY_OP_groupi32_n_13 WALLACE_CSA_DUMMY_OP_groupi32_n_15
+ WALLACE_CSA_DUMMY_OP_groupi32_n_31 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_44 sky130_fd_sc_hd__a31oi_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1341__7410 WALLACE_CSA_DUMMY_OP_groupi32_n_18
+ WALLACE_CSA_DUMMY_OP_groupi32_n_30 WALLACE_CSA_DUMMY_OP_groupi32_n_19
+ WALLACE_CSA_DUMMY_OP_groupi32_n_23 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_43 sky130_fd_sc_hd__o22ai_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1342__6417 WALLACE_CSA_DUMMY_OP_groupi32_n_19
+ WALLACE_CSA_DUMMY_OP_groupi32_n_30 WALLACE_CSA_DUMMY_OP_groupi32_n_11
+ WALLACE_CSA_DUMMY_OP_groupi32_n_23 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_42 sky130_fd_sc_hd__o22ai_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1343__5477 WALLACE_CSA_DUMMY_OP_groupi32_n_14
+ WALLACE_CSA_DUMMY_OP_groupi32_n_30 WALLACE_CSA_DUMMY_OP_groupi32_n_18
+ WALLACE_CSA_DUMMY_OP_groupi32_n_23 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_41 sky130_fd_sc_hd__o22ai_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1344__2398 WALLACE_CSA_DUMMY_OP_groupi32_n_29
+ TDC_out[5] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_40
+ sky130_fd_sc_hd__nor2b_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1345__5107 WALLACE_CSA_DUMMY_OP_groupi32_n_9
+ WALLACE_CSA_DUMMY_OP_groupi32_n_28 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_39 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1346__6260 WALLACE_CSA_DUMMY_OP_groupi32_n_24
+ WALLACE_CSA_DUMMY_OP_groupi32_n_0 WALLACE_CSA_DUMMY_OP_groupi32_n_25
+ TDC_out[0] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_38
+ sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1347__4319 WALLACE_CSA_DUMMY_OP_groupi32_n_25
+ WALLACE_CSA_DUMMY_OP_groupi32_n_0 WALLACE_CSA_DUMMY_OP_groupi32_n_22
+ TDC_out[0] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_37
+ sky130_fd_sc_hd__a22oi_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1348__8428 WALLACE_CSA_DUMMY_OP_groupi32_n_27
+ WALLACE_CSA_DUMMY_OP_groupi32_n_0 WALLACE_CSA_DUMMY_OP_groupi32_n_26
+ TDC_out[0] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_36
+ sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1349__5526 WALLACE_CSA_DUMMY_OP_groupi32_n_26
+ WALLACE_CSA_DUMMY_OP_groupi32_n_0 WALLACE_CSA_DUMMY_OP_groupi32_n_24
+ TDC_out[0] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_35
+ sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1350__6783 WALLACE_CSA_DUMMY_OP_groupi32_n_27
+ TDC_out[0] WALLACE_CSA_DUMMY_OP_groupi32_n_0
+ WALLACE_CSA_DUMMY_OP_groupi32_n_8 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_34 sky130_fd_sc_hd__a22o_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1351__3680 WALLACE_CSA_DUMMY_OP_groupi32_n_8
+ WALLACE_CSA_DUMMY_OP_groupi32_n_17 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_33 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1352__1617 WALLACE_CSA_DUMMY_OP_groupi32_n_8
+ WALLACE_CSA_DUMMY_OP_groupi32_n_23 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_32 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1353__2802 WALLACE_CSA_DUMMY_OP_groupi32_n_16
+ WALLACE_CSA_DUMMY_OP_groupi32_n_17 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_31 sky130_fd_sc_hd__nor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1354__1705 WALLACE_CSA_DUMMY_OP_groupi32_n_23
+ WALLACE_CSA_DUMMY_OP_groupi32_n_12 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_30 sky130_fd_sc_hd__nand2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1355__5122 Kp[0] TDC_out[3] TDC_out[4] 1416
+ 1417 1418 1419 WALLACE_CSA_DUMMY_OP_groupi32_n_29 sky130_fd_sc_hd__maj3_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1356__8246 Kp[0] TDC_out[1] TDC_out[2] 1420
+ 1421 1422 1423 WALLACE_CSA_DUMMY_OP_groupi32_n_28 sky130_fd_sc_hd__maj3_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1357__7098 TDC_out[1] Kp[5] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_22 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1358__6131 TDC_out[1] Kp[1] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_27 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1359__1881 TDC_out[1] Kp[2] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_26 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1360__5115 TDC_out[1] Kp[4] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_25 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1361__7482 TDC_out[1] Kp[3] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_24 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1362__4733 WALLACE_CSA_DUMMY_OP_groupi32_n_10
+ TDC_out[1] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_21
+ sky130_fd_sc_hd__and2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1363__6161 WALLACE_CSA_DUMMY_OP_groupi32_n_10
+ integrated[6] VGND VNB VPB VPWR WALLACE_CSA_DUMMY_OP_groupi32_n_20
+ sky130_fd_sc_hd__nor2b_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1364__9315 TDC_out[1] TDC_out[2] 1452 1453 1454
+ 1455 WALLACE_CSA_DUMMY_OP_groupi32_n_23 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1365__9945 TDC_out[5] Kp[1] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_16 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1366__2883 TDC_out[4] TDC_out[5] 1460 1461 1462
+ 1463 WALLACE_CSA_DUMMY_OP_groupi32_n_15 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1367__2346 TDC_out[3]
+ WALLACE_CSA_DUMMY_OP_groupi32_n_8 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_14 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1368__1666 TDC_out[5] Kp[0] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_13 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1369__7410 TDC_out[2] TDC_out[3] 1472 1473 1474
+ 1475 WALLACE_CSA_DUMMY_OP_groupi32_n_12 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1370__6417 Kp[3]
+ WALLACE_CSA_DUMMY_OP_groupi32_n_9 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_11 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1371__5477 Kp[2]
+ WALLACE_CSA_DUMMY_OP_groupi32_n_9 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_19 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1372__2398 Kp[1]
+ WALLACE_CSA_DUMMY_OP_groupi32_n_9 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_18 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1373__5107 TDC_out[4]
+ WALLACE_CSA_DUMMY_OP_groupi32_n_9 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_17 sky130_fd_sc_hd__xor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1375__6260 Kp[0] TDC_out[0] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_10 sky130_fd_sc_hd__nand2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1376 TDC_out[3] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_9 sky130_fd_sc_hd__inv_2
XWALLACE_CSA_DUMMY_OP_groupi32_g1377 Kp[0] VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_8 sky130_fd_sc_hd__inv_2
XWALLACE_CSA_DUMMY_OP_groupi32_drc_bufs WALLACE_CSA_DUMMY_OP_groupi32_n_59 1504
+ 1505 1506 1507 DLF_out[0] sky130_fd_sc_hd__buf_8
XWALLACE_CSA_DUMMY_OP_groupi32_drc_bufs1379 WALLACE_CSA_DUMMY_OP_groupi32_n_66
+ VGND VNB VPB VPWR DLF_out[1] sky130_fd_sc_hd__buf_8
XWALLACE_CSA_DUMMY_OP_groupi32_drc_bufs1380 WALLACE_CSA_DUMMY_OP_groupi32_n_71
+ VGND VNB VPB VPWR DLF_out[3] sky130_fd_sc_hd__buf_8
XWALLACE_CSA_DUMMY_OP_groupi32_drc_bufs1381 WALLACE_CSA_DUMMY_OP_groupi32_n_69
+ VGND VNB VPB VPWR DLF_out[2] sky130_fd_sc_hd__buf_8
XWALLACE_CSA_DUMMY_OP_groupi32_drc_bufs1382 WALLACE_CSA_DUMMY_OP_groupi32_n_1
+ VGND VNB VPB VPWR DLF_out[4] sky130_fd_sc_hd__buf_8
XWALLACE_CSA_DUMMY_OP_groupi32_g2__4319 WALLACE_CSA_DUMMY_OP_groupi32_n_67
+ WALLACE_CSA_DUMMY_OP_groupi32_n_70 VGND VNB VPB VPWR
+ WALLACE_CSA_DUMMY_OP_groupi32_n_1 sky130_fd_sc_hd__xnor2_1
XWALLACE_CSA_DUMMY_OP_groupi32_g1383__8428 TDC_out[0] TDC_out[1] 1528 1529 1530
+ 1531 WALLACE_CSA_DUMMY_OP_groupi32_n_0 sky130_fd_sc_hd__nor2b_1
.ENDS
